# Keil uVision project face_ai_demo.uvprojx, settings and files
target face_ai_demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: face_ai_demo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\include;..\..\..\include\generated;..\..\..\include\config;..\..\..\include\drivers;..\..\..\arch\arm\include;..\..\..\kernel\include;..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\lib\libc\minimal\include;..\..\..\boards\arm\f6721b_evb_176pin;..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\ulibs\hal\gree\include\lib\common;..\debug_include;..\inc\vj;..\inc\cam;..\inc\common;..\inc\lcd;..\inc\math;..\inc\module;..\inc\shell;..\..\face_ai;..\..\..\..\ext\lib\openmv\include;..\..\..\include\shell;..\..\..\drivers\camera\ov5640;..\spi;..\inc\lib;..\..\..\ext\hal\gree\include\driver;..\..\..\ext\hal\gree\driver\uart;..\..\..\ext\lib\openmv\include;..\..\..\..\ulibs\hal\gree\driver\pdm;..\..\..\..\ulibs\hal\gree\driver\dma;..\..\pdm
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x40000
  scatter file: .\face_ai_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: pdm_test_example.c
  group arch
    ../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group hal
    ../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../ulibs/hal/gree/driver/pdm/: gm_hal_pdm.c
  group kernel
    ../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c
    ./../../../kernel/: poll.c
  group board
    ../../../boards/arm/f6721b_evb_176pin/: pinmux.c
  group core
    ../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../lib/: ugelis_core_f6721b.lib
  group subsys
    ../../../subsys/random/: rand32_timer.c
    ../../../subsys/shell/: shell.c shell_service.c
    ../../../subsys/shell/modules/: kernel_service.c
    ../../../subsys/mm/: malloc_ext.c mem_ext.c
    ../../../subsys/console/: line_fifo.c
  group openmv
    ../../../ext/lib/openmv/source/: xalloc.c fmath.c
  group driver
    ../../../drivers/serial/: uart_gm.c
    ../../../drivers/console/: uart_console.c
    ../../../drivers/gpio/: gpio_gm.c
    ../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../drivers/dma/: dma_gm.c
  group Model
    ../Model/: IndexToCommand.c CYBase.h Group_1.h Group_2.h
  group Lib
    ../: DSpotter2.lib
