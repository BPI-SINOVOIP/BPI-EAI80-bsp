# Keil uVision project slave.uvprojx, settings and files
target slave (ARM-ADS)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IROM(0x00010000,0x100000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: slave +hex
  AfterMake: fromelf --bin --output=.\slave.bin .\slave.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=1
  c define: __USE_KEIL_,CONFIG_QR_DUAL_EN
  c misc: --gnu
  c include: ..\..\..\..\..\include;..\..\..\..\..\include\generated;..\..\..\..\..\include\config;..\..\..\..\..\include\drivers;..\..\..\..\..\arch\arm\include;..\..\..\..\..\kernel\include;..\..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\boards\arm\f6721b_evb_qfn80Pin;..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\..\ulibs\hal\gree\driver\adc;..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\..\ulibs\hal\gree\driver\rpc;..\..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\include\rpc\core;..\..\..\..\..\include\rpc\plugin;..\..\..\..\..\ext\lib\barcode\zbar_ext;..\..\..\..\..\ext\lib\barcode\zbar_ext\decoder;..\..\..\..\..\ext\lib\barcode\zbar_ext\qrcode;..\..\..\..\..\ext\lib\openmv\include;.\
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\slave.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
  group arch
    ../../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../../drivers/serial/: uart_gm.c
    ../../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../../drivers/console/: uart_console.c
  group hal
    ../../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../../ulibs/hal/gree/driver/adc/: gm_hal_adc.c
    ../../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../../ulibs/hal/gree/driver/rtc/: gm_hal_rtc.c gm_hal_utc.c
    ../../../../../../ulibs/hal/gree/driver/rpc/: gm_hal_rpc.c
  group board
    ../../../../../boards/arm/: pinmux.c
  group kobject
    ../../../../../kernel/: device.c mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c
  group lib
    ../../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../../lib/: ugelis_core_f6721b.lib
  group subsys
    ../../../../../subsys/rpc/core/: rpc_slave.c
    ../../../../../subsys/rpc/plugin/: rpc_plugin_imp.c rpc_plugin_qr.c rpc_plugin_yolo.c
    ../../../../../subsys/mm/: malloc_ext.c
  group libm
    ../../../../../ext/lib/jerry-libm/: acos.c asin.c atan.c atan2.c ceil.c exp.c fabs.c finite.c floor.c fmod.c isnan.c log.c nextafter.c pow.c sqrt.c trig.c
  group libc
    ../../../../../lib/libc/minimal/source/stdlib/: malloc.c
  group libopenmv
    ../../../../../ext/lib/openmv/source/: array.c collections.c edge.c fast.c filter.c fmath.c fsort.c haar.c imlib.c integral_mw.c orb.c rgb2rgb_tab.c sincos_tab.c sobel.c vibe.c xalloc.c xyz_tab.c
  group barcode
    ../../../../../ext/lib/barcode/zbar_ext/decoder/: decoder_interface.c
    ../../../../../ext/lib/barcode/zbar_ext/qrcode/: bch15_5.c binarize.c isaac.c qrdec.c qrdectxt.c rs.c util.c
    ../../../../../ext/lib/barcode/zbar_ext/: config.c decoder.c error.c image.c img_scanner.c refcnt.c scanner.c symbol.c
    ../../../../../ext/lib/barcode/zbar_ext/mempool/: zbar_mempool.c
