# Keil uVision project ui_demo.uvprojx, settings and files
target ui_demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x100000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ugelis_demo +hex
  AfterMake: fromelf -text -a -c -output=ugelis_demo.txt ugelis_demo.axf
  c flags: Optim=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\include;..\..\..\include\generated;..\..\..\include\config;..\..\..\include\drivers;..\..\..\arch\arm\include;..\..\..\kernel\include;..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\lib\libc\minimal\include;..\..\..\boards\arm\gm6721_evb_144pin;..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\ASR_LCD_qfn80;..\mdk;..\ui
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\ui_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: LCD_String.c pdm_test_example.c
  group arch
    ../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../drivers/serial/: uart_gm.c
    ../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../drivers/console/: uart_console.c
    ../../../drivers/gpio/: gpio_gm.c
    ../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../drivers/display/: display_gm6721x.c
    ../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../drivers/dma/: dma_gm.c
  group hal
    ../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../ulibs/hal/gree/driver/pdm/: gm_hal_pdm.c
    ../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
  group kernel
    ../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c device.c poll.c
  group board
    ../../../boards/arm/f6721b_evb_qfn80Pin/: pinmux.c
  group lib
    ../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../lib/: ugelis_core_f6721b.lib
    ../: DSpotter2.lib
  group ui
    ../ui/: draw.c
  group model
    ../Model/: CYBase.h Group_1.h Group_2.h IndexToCommand.c
