# Keil uVision project uncompressImage_demo.uvprojx, settings and files
target uncompressImage_demo (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IRAM(0xC0100000,0x20000) IROM(0x00010000,0x400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ugelis_demo +hex
  c flags: Optim=4 oTime=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\;..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\mdk;..\..\..\..\boards\arm
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: uncompressImage_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group board
    ../../../../boards/arm/f6721b_evb_176pin/: pinmux.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group hal
    ../../../../../ulibs/hal/gree/driver/sqi/: gm_hal_sqi.c gm_hal_sqi_host.c
    ../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
  group driver
    ../../../../drivers/dma/: dma_gm.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
  group kobject
    ../../../../kernel/: mailbox.c mempool.c mutex.c queue.c sem.c stack.c system_work_q.c timer.c poll.c mem_slab.c device.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
  group misc
    ../../../../subsys/mm/: dlmalloc.c dlmemory.c malloc_ext.c mem_ext.c
    ../../../../lib/load_compress_image/: load_compress_image.c
  group zlib
    ../../../../lib/zlib/: inflate.c uncompr.c deflate.c crc32.c adler32.c inffast.c inftrees.c trees.c zutil.c
