# Keil uVision project pdm_demo.uvprojx, settings and files
target i2c_demo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IRAM(0xC0100000,0x20000) IROM(0x00010000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ugelis_demo +hex
  AfterMake: fromelf --bin --output=i2c.bin ugelis_demo.axf
  AfterMake: fromelf --text -a -c --output=i2c.txt ugelis_demo.axf
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\driver\adc;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\samples\gm6721_prj\boot\include\arch;..\..\..\..\drivers\i2c;..\..\..\..\include;..\..\..\..\drivers\i2c;..\mdk;..\..\..\..\include;..\..\..\..\..\ulibs\hal\gree\driver\pdm
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: i2c_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: pdm_test_example.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/i2c/: i2c_gm.c
    ../../../../drivers/dma/: dma_gm.c
  group hal
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/adc/: gm_hal_adc.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/i2c/: gm_hal_i2c.c
    ../../../../../ulibs/hal/gree/driver/pdm/: gm_hal_pdm.c
  group kernel
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c system_work_q.c timer.c stack.c device.c
  group board
    ../../../../boards/arm/: pinmux.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
