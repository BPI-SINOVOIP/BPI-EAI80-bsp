# Keil uVision project dev_camera_jpeg.uvprojx, settings and files
target dev_camera_jpeg (ARM-ADS)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x100000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: dev_camera_jpeg +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\src;..\..\..\..\..\..\include;..\..\..\..\..\..\include\generated;..\..\..\..\..\..\include\config;..\..\..\..\..\..\include\drivers;..\..\..\..\..\..\arch\arm\include;..\..\..\..\..\..\kernel\include;..\..\..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\..\..\ulibs\hal\gree\driver\adc;..\..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\..\..\ulibs\hal\gree\driver\usb;..\..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\..\..\ulibs\midware\usb\include;..\..\..\..\..\..\..\ulibs\midware\usb\osa;..\..\..\..\..\..\..\ulibs\midware\usb\device;..\..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\..\subsys\mm;..\..\..\..\..\..\..\ulibs\midware\usb\device\class\video;..\..\dev_camera_jpeg_sw;..\..\..\..\..\..\boards\arm;..\..\..\..\..\imglib_src
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\dev_camera_jpeg.sct
  link misc: --diag-suppress=L6314
  group prj
    ../src/: main.c usb_device_descriptor.c video_mgr.c
  group arch
    ../../../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../../../drivers/serial/: uart_gm.c
    ../../../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../../../drivers/gpio/: gpio_gm.c
    ../../../../../../drivers/console/: uart_console.c
    ../../../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../../../drivers/camera/: vin_gm6721x.c vb_queue.c camera_interface.c
  group hal
    ../../../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../../../ulibs/hal/gree/driver/rtc/: gm_hal_rtc.c gm_hal_utc.c
    ../../../../../../../ulibs/hal/gree/driver/pes/: gm_hal_pes.c
    ../../../../../../../ulibs/hal/gree/driver/usb/: gm_hal_usb.c
    ../../../../../../../ulibs/hal/gree/driver/i2c/: gm_hal_i2c.c
    ../../../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../../../../ulibs/hal/gree/driver/kdp/: gm_hal_kdp.c
  group kernel
    ../../../../../../kernel/: device.c mailbox.c mem_slab.c mempool.c mutex.c pipes.c poll.c queue.c msg_q.c timer.c system_work_q.c stack.c sem.c
  group board
    ../../../../../../boards/arm/: pinmux.c
  group lib
    ../../../../../lib/: ugelis_core_f6721b.lib imgopt.lib
    ../../../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
  group subsys
    ../../../../../../subsys/random/: rand32_timer.c
    ../../../../../../subsys/mm/: malloc_ext.c mem_ext.c
  group usb-dev
    ../../../../../../../ulibs/midware/usb/device/: usb_device_ch9.c usb_device_class.c usb_device_dci.c usb_device_khci.c
  group usb-include
    ../../../../../../../ulibs/midware/usb/include/: usb.h usb_spec.h
  group usb_osa
    ../../../../../../../ulibs/midware/usb/osa/: usb_osa_ugelisos.c
  group usb-dev-class
    ../../../../../../../ulibs/midware/usb/device/class/video/: usb_device_video.c
