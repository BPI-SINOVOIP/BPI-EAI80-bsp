# Keil uVision project tim_demo.uvprojx, settings and files
target tim_demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: tim_demo +hex
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\driver\tim;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\mdk;..\..\..\..\include;..\..\..\..\include\generated\syscalls;..\..\..\..\boards\arm\f6721b_evb_176pin
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\tim_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/tim/: tim_gm.c
  group hal
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/tim/: gm_hal_tim.c
  group kernel
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c sched.c device.c
  group board
    ../../../../boards/arm/: pinmux.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
