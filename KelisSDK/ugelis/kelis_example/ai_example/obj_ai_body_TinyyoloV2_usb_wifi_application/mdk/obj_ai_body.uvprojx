# Keil uVision project obj_ai_body.uvprojx, settings and files
target obj_ai_body (ARM-ADS)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x100000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: obj_ai_detection
  AfterMake: fromelf -c .\obj\obj_ai_detection.axf -o .\obj\obj_ai_detection.dis
  AfterMake: fromelf --bin --output=.\obj\obj_ai_detection.bin .\obj\obj_ai_detection.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\arch\arm\include;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\src;..\..\..\..\subsys\fs;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\mm;..\src\inc\cam;..\src\inc\common;..\src\inc\lcd;..\src\inc\module;..\src\inc\shell;..\src\inc\vj;..\src\inc\wifi;..\..\..\..\boards\arm;..\mdk;..\src\inc\module;..\..\..\..\..\ulibs\midware\easynet_cross;..\..\..\..\..\ulibs\midware\openmv\include;..\..\..\..\..\ulibs\midware\obj_info;..\..\..\..\..\ulibs\midware\usb\device;..\..\..\..\..\ulibs\midware\usb\include;..\..\..\..\..\ulibs\midware\usb\osa;..\..\..\..\..\ulibs\midware\usb\device\class\video;..\src\inc\usb;..\src\inc\jpeg;..\..\obj_ai_body_TinyyoloV2_usb_wifi_application
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\obj_ai_body.sct
  link misc: --diag-suppress=L6314
  group prj
    ../src/: main.c post_yolo.c app_processor.c obj_info.c motor.c
    ../src/protocol/: objcmd.c
  group easynet_cross
    ../../../../../ulibs/midware/easynet_cross/: processor.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/display/: display_gm6721x.c
    ../../../../drivers/camera/: vb_queue.c vin_gm6721x.c
    ../../../../drivers/camera/ov5640/: ov5640.c
    ../../../../drivers/i2c/: i2c_bitbang.c i2c_gpio.c
    ../../../../drivers/dma/: dma_gm.c
    ../../../../kernel/: device.c
  group hal
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../../ulibs/hal/gree/driver/kdp/: gm_hal_kdp.c
    ../../../../../ulibs/hal/gree/driver/tim/: gm_hal_tim.c
    ../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../../ulibs/hal/gree/driver/usb/: gm_hal_usb.c
    ../../../../../ulibs/hal/gree/driver/sqi/: gm_hal_sqi.c gm_hal_sqi_host.c
  group kernel
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c poll.c
  group board
    ../../../../boards/arm/f6721b_evb_qfn80Pin/: pinmux.c
  group subsys
    ../../../../subsys/random/: rand32_timer.c
    ../../../../subsys/mm/: malloc_ext.c
    ../../../../subsys/shell/: shell.c shell_service.c
    ../../../../subsys/shell/modules/: kernel_service.c
    ../../../../subsys/console/: line_fifo.c
  group camera
    ../src/camera/: camera.c
  group lcd
    ../src/lcd/: draw.c lcd.c
  group shell
    ../src/shell/: ai_shell.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib processor_common.lib
  group storage
    ../../../../../ulibs/midware/easynet_cross/: storage.c
  group wifi
    ../src/wifi/: wifi.c
  group usb
    ../../../../../ulibs/midware/usb/include/: usb.h usb_spec.h
    ../../../../../ulibs/midware/usb/device/: usb_device_dci.c usb_device_ch9.c usb_device_class.c usb_device_khci.c
    ../../../../../ulibs/midware/usb/osa/: usb_osa_ugelisos.c
    ../../../../../ulibs/midware/usb/device/class/video/: usb_device_video.c
    ../src/usb/: usb_device_descriptor.c usb_virtual_camera.c video_mgr.c
  group jpeg
    ../src/jpeg/: jpeg.c
