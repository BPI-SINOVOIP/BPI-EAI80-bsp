# Keil uVision project ai.uvprojx, settings and files
target ai (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ai +hex
  AfterMake: fromelf -c .\ai.axf -o .\ai.dis
  AfterMake: fromelf --bin --output=.\ai.bin .\ai.axf
  c flags: Optim=4 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\debug_include;..\..\..\..\..\ext\lib\openmv\include;..\..\..\..\include\shell;..\..\..\..\drivers\camera\ov5640;..\spi;..\..\..\..\ext\hal\gree\include\driver;..\..\..\..\ext\hal\gree\driver\uart;..\..\..\..\ext\lib\openmv\include;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\driver\rtc;..\src\app;..\mdk_176pin;..\..\..\..\drivers\i2c;..\..\..\..\include\display;..\..\..\..\drivers\display\gt9147;..\..\..\..\..\ulibs\midware\easynet_cross;..\..\..\..\subsys\edgui;..\src\app\ui\edgui
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: ..\ai.sct
  link misc: --diag-suppress=L6314
  group prj
    ../src/app/: app.c main.c
    ../src/app/dev/: camera.c cmd.c dev.c flash.c gpio.c lcd.c
    ../src/app/faceai/: faceai.c face_detect.c face_recognize.c
    ../src/app/faceai/face_detect/: encode.c face_detection.c obj_detect.c
    ../src/app/lib/: algo.c image.c math.c print.c
    ../src/app/ui/: draw.c
    ../src/app/worker/: camera_worker.c event_worker.c lcd_worker.c loader_worker.c painter_worker.c post_worker.c pre_worker.c worker_manager.c easynet_worker.c
    ../src/app/objai/: obj_recognize.c objai.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/camera/: camera_interface.c vb_queue.c vin_gm6721x.c
    ../../../../drivers/display/: display_gm6721x.c touch_interface.c
  group hal
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../../ulibs/hal/gree/driver/kdp/: gm_hal_kdp.c
    ../../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../../ulibs/hal/gree/driver/sqi/: gm_hal_sqi.c gm_hal_sqi_host.c
    ../../../../../ulibs/hal/gree/driver/i2c/: gm_hal_i2c.c
  group kernel
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c device.c
    ./../../../../kernel/: poll.c
  group board
    ../../../../boards/arm/f6721b_evb_176pin/: pinmux.c
  group core
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
  group subsys
    ../../../../subsys/random/: rand32_timer.c
    ../../../../subsys/shell/: shell.c shell_service.c
    ../../../../subsys/shell/modules/: kernel_service.c
    ../../../../subsys/mm/: malloc_ext.c mem_ext.c
    ../../../../subsys/console/: line_fifo.c
  group easynet
    ../../../../../ulibs/midware/easynet_cross/: processor.c
    ../../../lib/: processor_common.lib
  group gui
    ../src/app/ui/ugui/: ugui_main.c ugui.c
  group speech
    ../../../../../ulibs/hal/gree/driver/pdm/: gm_hal_pdm.c
    ../../../../drivers/dma/: dma_gm.c
    ../src/app/speechai/: DSpotter2.lib speech_recognize.c speechai.c index2command.c
