# Keil uVision project kdp_process_lib.uvprojx, settings and files
target easynet (ARM-ADS)
  device: GM6721BLQFP144 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x200000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: bank_operation +hex (library)
  c flags: Optim=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\include;..\..\..\include\generated;..\..\..\..\include;..\..\..\include\drivers;..\..\..\arch\arm\include;..\..\..\kernel\include;..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm;..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\ulibs\hal\gree\include\lib\common;..\mdk;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\driver\kdp;..\..\..\..\..\ulibs\hal\gree\driver
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x200000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: ugelis_demo.sct
  link misc: --diag-suppress=L6314
  group easynet
    ../../../../../ulibs/midware/easynet/: bank_operation.c
