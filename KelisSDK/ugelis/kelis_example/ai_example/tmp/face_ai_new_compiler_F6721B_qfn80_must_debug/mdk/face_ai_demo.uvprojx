# Keil uVision project face_ai_demo.uvprojx, settings and files
target face_ai_demo (ARM-ADS)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x100000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: face_ai_demo +hex
  AfterMake: fromelf -c .\face_ai_demo.axf -o .\face_ai_demo.dis
  AfterMake: fromelf --bin --output=.\face_ai_demo.bin .\face_ai_demo.axf
  c flags: Optim=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\include;..\..\..\include\generated;..\..\..\include\config;..\..\..\include\drivers;..\..\..\arch\arm\include;..\..\..\kernel\include;..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\lib\libc\minimal\include;..\..\..\boards\arm\f6721b_evb_qfn80Pin;..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\ulibs\hal\gree\include\lib\common;..\debug_include;..\inc\vj;..\inc\cam;..\inc\common;..\inc\lcd;..\inc\math;..\inc\module;..\inc\shell;..\..\..\..\ext\lib\openmv\include;..\..\..\include\shell;..\..\..\drivers\camera\ov5640;..\spi;..\inc\lib;..\..\..\ext\hal\gree\include\driver;..\..\..\ext\hal\gree\driver\uart;..\..\..\ext\lib\openmv\include;..\..\..\..\ulibs\hal\gree\include\driver;..\..\face_ai_new_compiler_F6721B_qfn80_optimize
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\face_ai_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c processor.c
    ../camera/: camera.c
    ../face_detection/: encode.c faceDetection.c ObjDetectorC.c
    ../lcd/: draw.c lcd.c
    ../lib/: algo.c img.c
    ../math/: math.c tan_atan.c
    ../module/: storage.c
    ../shell/: ai_shell.c
    ../protocol/: facecmd.c protocol.c
  group arch
    ../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../drivers/serial/: uart_gm.c
    ../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../drivers/console/: uart_console.c
    ../../../drivers/gpio/: gpio_gm.c
    ../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../drivers/camera/ov5640/: ov5640.c
    ../../../drivers/camera/: vb_queue.c vin_gm6721x.c
    ../../../drivers/display/: display_gm6721x.c
    ../../../drivers/i2c/: i2c_gpio.c i2c_bitbang.c
    ../../../kernel/: device.c
  group hal
    ../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../ulibs/hal/gree/driver/kdp/: gm_hal_kdp.c
    ../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../ulibs/hal/gree/driver/sqi/: gm_hal_sqi.c gm_hal_sqi_host.c
  group kernel
    ../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c
    ./../../../kernel/: poll.c
  group board
    ../../../boards/arm/f6721b_evb_qfn80Pin/: pinmux.c
  group core
    ../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../lib/: ugelis_core_f6721b.lib
  group subsys
    ../../../subsys/random/: rand32_timer.c
    ../../../subsys/shell/: shell.c shell_service.c
    ../../../subsys/shell/modules/: kernel_service.c
    ../../../subsys/mm/: malloc_ext.c
    ../../../subsys/console/: line_fifo.c
