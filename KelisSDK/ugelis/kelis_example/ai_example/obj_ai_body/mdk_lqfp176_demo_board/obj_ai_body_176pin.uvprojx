# Keil uVision project obj_ai_body_176pin.uvprojx, settings and files
target obj_ai_body (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: obj_ai_detection
  AfterMake: fromelf -c .\obj\obj_ai_detection.axf -o .\obj\obj_ai_detection.dis
  AfterMake: fromelf --bin --output=.\obj\obj_ai_detection.bin .\obj\obj_ai_detection.axf
  c flags: Optim=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\arch\arm\include;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\src_demo_board\app;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\mm;..\src_demo_board\app\inc;..\..\..\..\boards\arm;..\mdk_lqfp176_demo_board;..\..\..\..\..\ulibs\midware\easynet_cross;..\..\..\..\..\ulibs\midware\openmv\include;..\..\..\..\drivers\i2c;..\src_demo_board\app\ui;..\src_demo_board\app\dev;..\src_demo_board\app\faceai
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\obj_ai_body.sct
  link misc: --diag-suppress=L6314
  group prj
    ../src_demo_board/app/: main.c app_processor.c app.c
    ../src_demo_board/app/dev/: camera.c lcd.c cmd.c dev.c flash.c gpio.c
    ../src_demo_board/app/ui/: draw.c
    ../src_demo_board/app/worker/: loader_worker.c worker_manager.c camera_worker.c lcd_worker.c easynet_worker.c event_worker.c post_worker.c pre_worker.c painter_worker.c
    ../src_demo_board/app/faceai/: faceai.c face_detect.c
    ../../face_ai/src/app/dev/: touchpad.c
  group easynet_cross
    ../../../../../ulibs/midware/easynet_cross/: processor.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/display/: display_gm6721x.c
    ../../../../drivers/camera/: vb_queue.c vin_gm6721x.c camera_interface.c
  group hal
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../../ulibs/hal/gree/driver/kdp/: gm_hal_kdp.c
    ../../../../../ulibs/hal/gree/driver/tim/: gm_hal_tim.c
    ../../../../../ulibs/hal/gree/driver/sqi/: gm_hal_sqi.c gm_hal_sqi_host.c
    ../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../../ulibs/hal/gree/driver/i2c/: gm_hal_i2c.c
  group kernel
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c poll.c device.c
  group board
    ../../../../boards/arm/f6721b_evb_176pin/: pinmux.c
  group subsys
    ../../../../subsys/random/: rand32_timer.c
    ../../../../subsys/mm/: malloc_ext.c
    ../../../../subsys/shell/: shell.c shell_service.c
    ../../../../subsys/shell/modules/: kernel_service.c
    ../../../../subsys/console/: line_fifo.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib processor_common.lib
  group storage
    ../../../../../ulibs/midware/easynet_cross/: storage.c
