# Keil uVision project face_ai_demo.uvprojx, settings and files
target face_ai_demo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IRAM(0xC0100000,0x20000) IROM(0x00010000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: face_ai_demo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\include;..\..\..\include\generated;..\..\..\include\config;..\..\..\include\drivers;..\..\..\arch\arm\include;..\..\..\kernel\include;..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\lib\libc\minimal\include;..\..\..\boards\arm\f6721b_evb_176pin;..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\ulibs\hal\gree\include\lib\common;..\debug_include;..\inc\vj;..\inc\cam;..\inc\common;..\inc\lcd;..\inc\math;..\inc\module;..\inc\shell;..\..\face_ai;..\..\..\..\ext\lib\openmv\include;..\..\..\include\shell;..\..\..\drivers\camera\ov5640;..\inc\lib;..\..\..\ext\hal\gree\include\driver;..\..\..\ext\hal\gree\driver\uart;..\..\..\ext\lib\openmv\include;..\..\..\..\ulibs\hal\gree\driver\pdm;..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\include;..\..\..\..\drivers;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\pdm_QFN80;..\..\..\..\..\ulibs\hal\gree\driver\clock;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\driver\pdm;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\reset;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\clock;..\..\..\..\arch\arm\include;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\include\generated;..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\..\ulibs\hal\gree\driver\reset;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\clock;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\boards\arm;..\..\..\..\kernel\include;..\..\..\..\ext\lib\openmv\source;..\..\..\..\include\drivers\console;..\..\..\..\include\drivers;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\driver
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\face_ai_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: pdm_test_example.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group hal
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/pdm/: gm_hal_pdm.c
    ../../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
  group kernel
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c poll.c device.c
  group board
    ../../../../boards/arm/: pinmux.c
  group subsys
    ../../../../subsys/random/: rand32_timer.c
    ../../../../subsys/shell/: shell.c shell_service.c
    ../../../../subsys/shell/modules/: kernel_service.c
    ../../../../subsys/console/: line_fifo.c
    ../../../../subsys/mm/: malloc_ext.c mem_ext.c
  group openmv
    ../../../../ext/lib/openmv/source/: xalloc.c fmath.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/dma/: dma_gm.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
