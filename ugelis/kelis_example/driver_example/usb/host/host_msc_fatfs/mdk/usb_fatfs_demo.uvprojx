# Keil uVision project usb_fatfs_demo.uvprojx, settings and files
target usb_fatfs_demo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GM6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: usb_fatfs_demo +hex
  AfterMake: fromelf -c .\obj\usb_fatfs_demo.axf -o .\obj\usb_fatfs_demo.dis
  AfterMake: fromelf --bin --output=.\obj\usb_fatfs_demo.bin .\obj\usb_fatfs_demo.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\..\include;..\..\..\..\..\include\generated;..\..\..\..\..\include\config;..\..\..\..\..\include\drivers;..\..\..\..\..\arch\arm\include;..\..\..\..\..\kernel\include;..\..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\boards\arm\gm6721_evb_144pin;..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\..\ulibs\hal\gree\driver\adc;..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\..\ulibs\hal\gree\driver\usb;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\..\ulibs\midware\usb\host;..\..\..\..\..\..\ulibs\midware\usb\include;..\..\..\..\..\..\ulibs\midware\usb\osa;..\..\..\..\..\..\ulibs\midware\usb\host\class\msc;..\..\..\..\..\..\ulibs\midware\usb\host\class;..\..\..\..\..\subsys\disk;..\..\host_msc_fatfs;..\..\..\..\..\..\ulibs\midware\fs;..\..\..\..\..\..\ulibs\midware\fs\fat;..\src;..\..\..\..\..\subsys\fs;..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\subsys\mm;..\mdk
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\usb_fatfs_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../src/: main.c host_msd_fatfs.c
  group arch
    ../../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../../drivers/serial/: uart_gm.c
    ../../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../../drivers/console/: uart_console.c
    ../../../../../drivers/gpio/: gpio_gm.c
    ../../../../../drivers/pinmux/gm/: pinmux_gm.c
  group hal
    ../../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../../ulibs/hal/gree/driver/rtc/: gm_hal_rtc.c gm_hal_utc.c
    ../../../../../../ulibs/hal/gree/driver/pes/: gm_hal_pes.c
    ../../../../../../ulibs/hal/gree/driver/usb/: gm_hal_usb.c
  group kernel
    ../../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c poll.c
  group board
    ../../../../../boards/arm/gm6721_evb_144pin/: pinmux.c
  group lib
    ../../../../lib/: ugelis_core.lib
    ../../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
  group subsys
    ../../../../../subsys/fs/: fs.c fat_fs.c
    ../../../../../subsys/random/: rand32_timer.c
    ../../../../../subsys/mm/: malloc_ext.c
    ../../../../../subsys/fs/fat/: ff.c zfs_diskio.c
  group usb-host
    ../../../../../subsys/usb_gm/host/: usb_host_devices.c usb_host_framework.c usb_host_hci.c usb_host_khci.c
  group usb-include
    ../../../../../subsys/usb_gm/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../subsys/usb_gm/osa/: usb_osa_ugelisos.c
  group usb-host-class
    ../../../../../subsys/usb_gm/host/class/msc/: usb_host_msd.c usb_host_msd_ufi.c
    ../../../../../subsys/usb_gm/host/class/: usb_host_hub.c usb_host_hub_app.c
  group fatfs-src
    ../../../../../subsys/disk/: gm_usb_disk_ugelis.c disk_access.c disk_access_usb.c
  group fatfs-include
    ../../../../../subsys/disk/: gm_usb_disk.h
