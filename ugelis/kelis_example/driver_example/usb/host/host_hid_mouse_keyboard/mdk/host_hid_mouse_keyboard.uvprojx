# Keil uVision project host_hid_mouse_keyboard.uvprojx, settings and files
target host_hid_mouse_keyboard (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GM6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: host_hid_mouse_keyboard +hex
  AfterMake: fromelf -c .\obj\host_hid_mouse_keyboard.axf -o .\obj\host_hid_mouse_keyboard.dis
  AfterMake: fromelf --bin --output=.\obj\host_hid_mouse_keyboard.bin .\obj\host_hid_mouse_keyboard.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\..\include;..\..\..\..\..\include\generated;..\..\..\..\..\include\config;..\..\..\..\..\include\drivers;..\..\..\..\..\arch\arm\include;..\..\..\..\..\kernel\include;..\..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\boards\arm\gm6721_evb_144pin;..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\..\ulibs\hal\gree\driver\adc;..\..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\..\ulibs\hal\gree\driver\usb;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\..\ulibs\midware\usb\host;..\..\..\..\..\..\ulibs\midware\usb\include;..\..\..\..\..\..\ulibs\midware\usb\osa;..\..\..\..\..\..\ulibs\midware\usb\host\class\hid;..\..\..\..\..\..\ulibs\midware\usb\host\class;..\..\..\..\..\subsys\disk;..\src;..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\subsys\mm;..\..\host_hid_mouse_keyboard
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\host_hid_mouse_keyboard.sct
  link misc: --diag-suppress=L6314
  group prj
    ../src/: main.c host_keyboard.c host_mouse.c
  group arch
    ../../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../../drivers/serial/: uart_gm.c
    ../../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../../drivers/console/: uart_console.c
    ../../../../../drivers/gpio/: gpio_gm.c
    ../../../../../drivers/pinmux/gm/: pinmux_gm.c
  group hal
    ../../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../../ulibs/hal/gree/driver/rtc/: gm_hal_rtc.c gm_hal_utc.c
    ../../../../../../ulibs/hal/gree/driver/pes/: gm_hal_pes.c
    ../../../../../../ulibs/hal/gree/driver/usb/: gm_hal_usb.c
  group kernel
    ../../../../../kernel/: alert.c atomic_c.c compiler_stack_protect.c device.c errno.c idle.c init.c int_latency_bench.c mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sched.c sem.c smp.c stack.c sys_clock.c system_work_q.c thread.c thread_abort.c timer.c version.c work_q.c poll.c
  group board
    ../../../../../boards/arm/gm6721_evb_144pin/: pinmux.c
  group lib
    ../../../../../misc/: printk.c
    ../../../../../lib/mempool/: mempool.c
    ../../../../../lib/rbtree/: rb.c
    ../../../../../lib/: thread_entry.c
    ../../../../../lib/libc/minimal/source/stdout/: stdout_console.c
  group core-armcc
    ../../../../../arch/arm/core-armcc/: thread_abort.c thread.c sys_fatal_error_handler.c swap_helper.S swap.c isr_wrapper.S irq_relay.S irq_offload.c irq_manage.c irq_init.c fault_s.S fault.c fatal.c exc_exit.S cpu_idle.S
    ../../../../../arch/arm/core-armcc/offsets/: offsets.c
    ../../../../../arch/arm/core-armcc/cortex_m/: vector_table.S scb.c reset.S prep_c.c nmi_on_reset.S nmi.c exc_manage.c
    ../../../../../arch/arm/soc/gree_gm/common/: arm_mpu_regions.c
    ../../../../../arch/common/: isr_tables.c timing_info_bench.c
  group subsys
    ../../../../../subsys/random/: rand32_timer.c
    ../../../../../subsys/mm/: malloc_ext.c
  group usb-host
    ../../../../../../ulibs/midware/usb/host/: usb_host_devices.c usb_host_framework.c usb_host_hci.c usb_host_khci.c
  group usb-include
    ../../../../../../ulibs/midware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../ulibs/midware/usb/osa/: usb_osa_ugelisos.c
  group usb-host-class
    ../../../../../../ulibs/midware/usb/host/class/: usb_host_hub.c usb_host_hub_app.c usb_host_hub.h usb_host_hub_app.h
    ../../../../../../ulibs/midware/usb/host/class/hid/: usb_host_hid.c usb_host_hid.h
