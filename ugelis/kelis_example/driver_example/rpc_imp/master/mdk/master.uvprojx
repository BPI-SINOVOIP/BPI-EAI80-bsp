# Keil uVision project master.uvprojx, settings and files
target master (ARM-ADS)
  device: GM6721BLQFP144 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x200000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: master +hex
  c flags: Optim=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\include\drivers;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm\gm6721_evb_144pin;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\driver\adc;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\driver\rpc;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\;..\..\..\..\ext\lib\openmv\include;..\..\..\..\include\rpc\core;..\..\..\..\include\rpc\plugin;..\..\..\..\ext\lib\openmv\include
  memory RVCT4: ROM 0x10000 size 0x200000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\master.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/display/: display_gm6721x.c
    ../../../../drivers/camera/: vb_queue.c vin_gm6721x.c
    ../../../../drivers/camera/ov5640/: ov5640.c
  group hal
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/rpc/: gm_hal_rpc.c
    ../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
  group board
    ../../../../boards/arm/gm6721_evb_144pin/: pinmux.c
  group kobject
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c
  group lib
    ../../../lib/: ugelis_core.lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
  group subsys
    ../../../../subsys/rpc/core/: rpc_master.c
    ../../../../subsys/mm/: malloc_ext.c
  group libm
    ../../../../ext/lib/jerry-libm/: acos.c asin.c atan.c atan2.c ceil.c exp.c fabs.c finite.c floor.c fmod.c isnan.c log.c nextafter.c pow.c sqrt.c trig.c
  group libc
    ../../../../lib/libc/minimal/source/stdlib/: malloc.c
  group libopenmv
    ../../../../ext/lib/openmv/source/: array.c collections.c edge.c fast.c filter.c fmath.c fsort.c haar.c imlib.c integral_mw.c orb.c rgb2rgb_tab.c sincos_tab.c sobel.c vibe.c xalloc.c xyz_tab.c
