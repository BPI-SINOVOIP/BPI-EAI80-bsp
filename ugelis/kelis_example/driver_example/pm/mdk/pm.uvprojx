# Keil uVision project pm.uvprojx, settings and files
target pm (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IRAM(0xC0100000,0x20000) IROM(0x00010000,0x400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: pm +hex
  AfterMake: fromelf --bin --output=pm.bin  pm.axf
  AfterMake: fromelf --text -a -c --output=pm.dis  pm.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\;..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\mdk
  asm define: __USE_KEIL_
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: pm.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
    ../../../../arch/arm/core-armcc/cortex_m/: prep_c.c
  group board
    ../../../../boards/arm/: pinmux.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group hal
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../../ulibs/hal/gree/driver/power/: gm_hal_power.c
    ../../../../../ulibs/hal/gree/driver/rtc/: gm_hal_rtc.c gm_hal_utc.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/dma/: dma_gm.c
    ../../../../drivers/pm/: pm_core.c power_gm.c
    ../../../../drivers/pm/powe_armcc_asm/: power_core_asm.s power_gm_asm.s
    ../../../../drivers/rtc/: rtc_gm.c
  group kobject
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c device.c
    ../../../../subsys/mm/: dlmalloc.c dlmemory.c malloc_ext.c mem_ext.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
