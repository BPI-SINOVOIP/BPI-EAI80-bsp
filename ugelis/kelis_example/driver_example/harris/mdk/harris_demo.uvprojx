# Keil uVision project harris_demo.uvprojx, settings and files
target harris_demo (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ugelis_demo +hex
  c flags: Optim=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\harris;..\mdk;..\..\..\..\..\ulibs\midware\openmv\include;..\..\..\..\..\ulibs\midware\openmv\source;..\..\..\..\drivers\i2c
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x200000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\harris_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/camera/ov5640/: ov5640.c
    ../../../../drivers/camera/: vb_queue.c vin_gm6721x.c
    ../../../../drivers/display/: display_gm6721x.c
    ../../../../drivers/i2c/: i2c_gm.c
  group hal
    ../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/i2c/: gm_hal_i2c.c
  group kobject
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c device.c
  group board
    ../../../../boards/arm/: pinmux.c
  group lib
    ./../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
  group subsys
    ../../../../subsys/mm/: malloc_ext.c
  group openmv
    ../../../../../ulibs/midware/openmv/source/: array.c fast.c imlib.c integral_mw.c sincos_tab.c xalloc.c
