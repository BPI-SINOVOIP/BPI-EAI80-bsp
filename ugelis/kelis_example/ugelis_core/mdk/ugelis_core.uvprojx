# Keil uVision project ugelis_core.uvprojx, settings and files
target ugelis_core (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ugelis_core +hex (library)
  c flags: Optim=4 oTime=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\include;..\..\..\include\generated;..\..\..\include\config;..\..\..\include\drivers;..\..\..\arch\arm\include;..\..\..\kernel\include;..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\lib\libc\minimal\include;..\..\..\boards\arm\gm6721_evb_144pin;..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\ulibs\hal\gree\include\lib\common;..\mdk
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: ugelis_demo.sct
  link misc: --diag-suppress=L6314
  group common
    ../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../drivers/timer/: cortex_m_systick.c
  group hal
    ../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
  group kernel
    ../../../kernel/: alert.c atomic_c.c compiler_stack_protect.c device.c errno.c idle.c init.c int_latency_bench.c sched.c smp.c sys_clock.c thread.c thread_abort.c version.c work_q.c
  group lib
    ../../../misc/: printk.c
    ../../../lib/mempool/: mempool.c
    ../../../lib/rbtree/: rb.c
    ../../../lib/: thread_entry.c
    ../../../lib/libc/minimal/source/stdout/: prf.c stdout_console.c
    ../../../lib/libc/minimal/source/stdlib/: atoi.c strtol.c strtoul.c
  group core-armcc
    ../../../arch/arm/core-armcc/: thread_abort.c thread.c sys_fatal_error_handler.c swap_helper.S swap.c isr_wrapper.S irq_relay.S irq_offload.c irq_manage.c irq_init.c fault_s.S fault.c fatal.c exc_exit.S cpu_idle.S
    ../../../arch/arm/core-armcc/offsets/: offsets.c
    ../../../arch/arm/core-armcc/cortex_m/: scb.c reset.S prep_c.c nmi_on_reset.S nmi.c exc_manage.c
    ../../../arch/arm/soc/gree_gm/common/: arm_mpu_regions.c
    ../../../arch/common/: isr_tables.c timing_info_bench.c
  group subsys
    ../../../subsys/random/: rand32_timer.c
