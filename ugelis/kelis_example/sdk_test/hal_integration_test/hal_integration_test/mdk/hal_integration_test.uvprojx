# Keil uVision project hal_integration_test.uvprojx, settings and files
target hal_integration_test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IRAM(0xC0100000,0x20000) IROM(0x00010000,0x400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: hal_integration_test +hex
  AfterMake: fromelf -c .\Objects\hal_integration_test.axf -o .\Objects\hal_integration_test.dis
  AfterMake: fromelf --bin --output=.\hal_integration_test.bin .\Objects\hal_integration_test.axf
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\;..\..\..\..\..\include;..\..\..\..\..\include\generated;..\..\..\..\..\include\config;..\..\..\..\..\include\drivers;..\..\..\..\..\arch\arm\include;..\..\..\..\..\kernel\include;..\..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\boards\arm;..\..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\mdk;..\..\..\..\..\ztest\include;..\..\..\..\..\tests\include;..\..\..\..\lib;..\lvd_hal;..\rtc_hal;..\dac_hal;..\wwdg_hal;..\iwdg_hal;..\dma_hal;..\gpio_hal;..\adc_hal;..\acmp_hal;..\i2c_hal;..\btm_hal;..\tim_hal;..\..\..\..\..\..\ulibs\hal\gree\driver\btm;..\uart_hal;..\can_hal;..\mmc_hal;..\pes_hal;..\imp_hal;..\vout_hal;..\sai_hal
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\hal_integration_test.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
  group arch
    ../../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group board
    ../../../../../boards/arm/: pinmux.c
  group common
    ../../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group hal
    ../../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../../ulibs/hal/gree/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../../../ulibs/hal/gree/driver/lvd/: gm_hal_lvd.c
    ../../../../../../ulibs/hal/gree/driver/rtc/: gm_hal_rtc.c gm_hal_utc.c
    ../../../../../../ulibs/hal/gree/driver/dac/: gm_hal_dac.c
    ../../../../../../ulibs/hal/gree/driver/wwdg/: gm_hal_wwdg.c
    ../../../../../../ulibs/hal/gree/driver/iwdg/: gm_hal_iwdg.c
    ../../../../../../ulibs/hal/gree/driver/acmp/: gm_hal_acmp.c
    ../../../../../../ulibs/hal/gree/driver/adc/: gm_hal_adc.c
    ../../../../../../ulibs/hal/gree/driver/i2c/: gm_hal_i2c.c
    ../../../../../../ulibs/hal/gree/driver/tim/: gm_hal_tim.c
    ../../../../../../ulibs/hal/gree/driver/btm/: gm_hal_btm.c
    ../../../../../../ulibs/hal/gree/driver/can/: gm_hal_can.c
    ../../../../../../ulibs/hal/gree/driver/mmc/block/: hal_mmc.c
    ../../../../../../ulibs/hal/gree/driver/mmc/core/: hal_mmc_core.c
    ../../../../../../ulibs/hal/gree/driver/mmc/host/: gm_hal_mmc_host.c
    ../../../../../../ulibs/hal/gree/driver/pes/: gm_hal_pes.c
    ../../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../../ulibs/hal/gree/driver/sai/: gm_hal_sai.c
  group driver
    ../../../../../drivers/serial/: uart_gm.c
    ../../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../../drivers/console/: uart_console.c
    ../../../../../drivers/gpio/: gpio_gm.c
    ../../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../../drivers/dma/: dma_gm.c
  group kernel
    ../../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c device.c
  group lib
    ../../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../../lib/: ugelis_core_f6721b.lib
  group ztest
    ../../../../../ztest/src/: ztest.c ztest_mock.c
  group hal_test
    ../lvd_hal/: gm_hal_test_lvd.c
    ../rtc_hal/: gm_hal_test_rtc.c
    ../dac_hal/: dac_test.c
    ../wwdg_hal/: gm_test_wwdg.c
    ../iwdg_hal/: gm_test_iwdg.c
    ../gpio_hal/: gpio_test.c
    ../dma_hal/: dma_test.c
    ../acmp_hal/: acmp_test.c
    ../adc_hal/: adc_test.c
    ../i2c_hal/: i2c_test.c
    ../tim_hal/: gm_hal_test_tim.c
    ../btm_hal/: gm_hal_test_btm.c
    ../uart_hal/: gm_hal_test_uart.c
    ../can_hal/: can_test.c
    ../mmc_hal/: mmc_test.c
    ../pes_hal/: pes_test.c
    ../imp_hal/: imp_test.c
    ../vout_hal/: vout_test.c
    ../sai_hal/: sai_test.c
