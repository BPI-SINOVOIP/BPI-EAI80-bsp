# Keil uVision project fs_demo.uvprojx, settings and files
target fs_demo (ARM-ADS)
  device: GM6721BLQFP144 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x200000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: fs_demo +hex
  c flags: Optim=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\include;..\..\..\include\generated;..\..\..\include\config;..\..\..\include\drivers;..\..\..\arch\arm\include;..\..\..\kernel\include;..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\rabbit;..\..\..\..\rabbit\include;..\..\..\..\rabbit\include\driver;..\..\..\..\rabbit\driver;..\..\..\..\rabbit\include\lib\common;..\..\..\..\rabbit\include\arch\arm\soc;..\..\..\..\rabbit\include\cmsis;..\..\..\..\rabbit\include\arch\arm\cpu;..\..\..\..\rabbit\include\config;..\..\..\lib\libc\minimal\include;..\..\..\boards\arm\gm6721_evb_144pin;..\..\..\ztest\include;..\..\..\tests\include
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x200000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\fs_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
    ../kernel/: timer_t.c
  group arch
    ../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../rabbit/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../rabbit/lib/common/: gm_common.c
  group driver
    ../../../drivers/serial/: uart_gm.c
    ../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../drivers/console/: uart_console.c
    ../../../drivers/gpio/: gpio_gm.c
    ../../../drivers/pinmux/gm/: pinmux_gm.c
  group hal
    ../../../../rabbit/driver/uart/: gm_hal_uart.c
    ../../../../rabbit/driver/gpio/: gm_hal_gpio.c
    ../../../../rabbit/driver/sqi/: gm_hal_sqi_mx25.c
    ../../../../rabbit/driver/dma/: gm_hal_dma.c
    ../../../../rabbit/arch/arm/cpu/cache/: gm_hal_cache.c
    ../../../../rabbit/driver/clock/: gm_hal_clock.c
    ../../../../rabbit/driver/reset/: gm_hal_reset.c
  group kernel
    ../../../kernel/: alert.c atomic_c.c compiler_stack_protect.c device.c errno.c idle.c init.c int_latency_bench.c mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sched.c sem.c smp.c stack.c sys_clock.c system_work_q.c thread.c thread_abort.c timer.c version.c work_q.c
  group board
    ../../../boards/arm/gm6721_evb_144pin/: pinmux.c
  group lib
    ../../../misc/: printk.c reboot.c
    ../../../lib/mempool/: mempool.c
    ../../../lib/libc/newlib/: libc-hooks.c
    ../../../lib/rbtree/: rb.c
    ../../../lib/: thread_entry.c
    ../../../lib/libc/minimal/source/stdout/: prf.c
    ../../../lib/libc/minimal/source/stdlib/: atoi.c strtol.c strtoul.c
  group core-armcc
    ../../../arch/arm/core-armcc/: thread_abort.c thread.c sys_fatal_error_handler.c swap_helper.S swap.c isr_wrapper.S irq_relay.S irq_offload.c irq_manage.c irq_init.c fault_s.S fault.c fatal.c exc_exit.S cpu_idle.S
    ../../../arch/arm/core-armcc/offsets/: offsets.c
    ../../../arch/arm/core-armcc/cortex_m/: vector_table.S scb.c reset.S prep_c.c nmi_on_reset.S nmi.c exc_manage.c
    ../../../arch/arm/soc/gree_gm/common/: arm_mpu_regions.c
    ../../../arch/common/: isr_tables.c timing_info_bench.c
  group subsys
    ../../../subsys/random/: rand32_timer.c
  group ztest
    ../../../ztest/src/: ztest.c ztest_mock.c
