# Keil uVision project corner_detector.uvprojx, settings and files
target corner_detector (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: corner_detector
  AfterMake: fromelf -c .\obj\corner_detector.axf -o .\obj\corner_detector.dis
  AfterMake: fromelf --bin --output=.\obj\corner_detector.bin .\obj\corner_detector.axf
  c flags: Optim=3 oTime=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\;..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\src;..\..\..\..\subsys\fs;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\mm;..\..\..\..\boards\arm\f6721b_evb_qfn80Pin;..\mdk;..\..\..\..\..\ulibs\midware\openmv\include;..\..\..\..\subsys\fs\fat\include;..\src\ui
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\corner_detector.sct
  link misc: --diag-suppress=L6314
  group prj
    ../src/: main.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c weak_fixup.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/camera/: camera_interface.c vin_gm6721x.c vb_queue.c
    ../../../../drivers/flash/: flash_gm.c
    ../../../../drivers/display/: display_gm6721x.c
  group hal
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
    ../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../../ulibs/hal/gree/driver/sqi/: gm_hal_sqi.c gm_hal_sqi_host.c
  group kernel
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c poll.c device.c
  group board
    ../../../../boards/arm/: pinmux.c
  group subsys
    ../../../../subsys/random/: rand32_timer.c
    ../../../../subsys/shell/: shell.c shell_service.c
    ../../../../subsys/mm/: dlmalloc.c dlmemory.c
    ../../../../subsys/shell/modules/: kernel_service.c
    ../../../../subsys/console/: line_fifo.c
  group lib
    ../../../lib/: ugelis_core_f6721b.lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
  group openmv
    ../../../../../ulibs/midware/openmv/source/: array.c fast.c imlib.c xalloc.c fmath.c orb.c sincos_tab.c clahe.c filter.c fsort.c kmeans.c lbp.c
  group fs
    ../../../../subsys/fs/: fat_fs.c fs.c
    ../../../../subsys/fs/fat/: ff.c
  group disk
    ../../../../subsys/disk/: disk_access.c disk_access_flash.c
    ../../../../subsys/fs/fat/: zfs_diskio.c
  group ui
    ../src/ui/: draw.c
