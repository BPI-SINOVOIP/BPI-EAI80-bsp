# Keil uVision project edgui_demo.uvprojx, settings and files
target edgui_demo (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: edgui_demo +hex
  c flags: Optim=1 oTime=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\;..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\mdk;..\..\..\..\subsys\edgui;..\..\..\..\include\display;..\apps\video
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: edgui_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../: main.c
    ../apps/demo/: demo.c img_bubble_pattern.c
    ../apps/tests/edgui_test_theme/: edgui_test_theme_1.c edgui_test_theme_2.c
    ../apps/tutorial/8_animations/: edgui_tutorial_animations.c
    ../apps/tutorial/9_responsive/: edgui_tutorial_responsive.c
    ../apps/tutorial/2_objects/: edgui_tutorial_objects.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group board
    ../../../../boards/arm/: pinmux.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group hal
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/vout/: gm_hal_vout.c
    ../../../../../ulibs/hal/gree/driver/imp/: gm_hal_imp.c
    ../../../../../ulibs/hal/gree/driver/i2c/: gm_hal_i2c.c
    ../../../../../ulibs/hal/gree/driver/vin/: gm_hal_vin.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/display/: display_gm6721x.c touch_interface.c
  group kobject
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c stack.c sem.c system_work_q.c timer.c device.c poll.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: edgui.lib ugelis_core_f6721b.lib
  group video
    ../../../../subsys/mm/: malloc_ext.c
    ../../../../drivers/camera/: camera_interface.c vin_gm6721x.c vb_queue.c
    ../apps/video/: video_demo.c
    ../apps/video/dev/: camera.c lcd.c
    ../apps/video/worker/: camera_worker.c lcd_worker.c worker_manager.c
