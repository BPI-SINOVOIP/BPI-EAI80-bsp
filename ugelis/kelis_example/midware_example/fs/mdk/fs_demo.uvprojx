# Keil uVision project fs_demo.uvprojx, settings and files
target fs_demo (ARM-ADS)
  device: F6721BLQFP80 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x100000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: fs_demo +hex
  c flags: Optim=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\include\generated;..\..\..\..\include\config;..\..\..\..\include\drivers;..\..\..\..\arch\arm\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\soc\gree_gm\gm6721x;..\..\..\..\lib\libc\minimal\include;..\..\..\..\boards\arm;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\fs;..\..\..\..\ztest\include;..\..\..\..\tests\include;..\..\..\..\subsys\fs\fat\include
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x100000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  scatter file: .\fs_demo.sct
  link misc: --diag-suppress=L6314
  group prj
    ../fs/fat_fs_api/: test_fat_dir.c test_fat_file.c test_fat_fs.c test_fat_mount.c common.c main.c
  group arch
    ../../../../arch/arm/soc/gree_gm/gm6721x/: soc.c
    ../../../../../ulibs/hal/gree/arch/arm/soc/gm6721x/: soc_gm6721x.c
  group board
    ../../../../boards/arm/: pinmux.c
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
  group hal
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/sqi/: gm_hal_sqi.c gm_hal_sqi_host.c
  group driver
    ../../../../drivers/serial/: uart_gm.c
    ../../../../drivers/timer/: cortex_m_systick.c sys_clock_init.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/gpio/: gpio_gm.c
    ../../../../drivers/pinmux/gm/: pinmux_gm.c
    ../../../../drivers/flash/: flash_gm.c
  group kobject
    ../../../../kernel/: mailbox.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c queue.c sem.c stack.c system_work_q.c timer.c device.c
  group lib
    ../../../../arch/arm/core-armcc/cortex_m/: vector_table.S
    ../../../lib/: ugelis_core_f6721b.lib
  group ztest
    ../../../../ztest/src/: ztest.c ztest_mock.c
  group fs
    ../../../../subsys/fs/: fat_fs.c fs.c shell.c
    ../../../../subsys/fs/fat/: ff.c
    ../../../../subsys/fs/fat/option/: syscall.c unicode.c
  group disk
    ../../../../subsys/disk/: disk_access.c disk_access_flash.c
    ../../../../subsys/fs/fat/: zfs_diskio.c
