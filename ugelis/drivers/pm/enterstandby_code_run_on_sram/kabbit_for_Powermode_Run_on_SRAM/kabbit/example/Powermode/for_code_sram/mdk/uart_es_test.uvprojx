# Keil uVision project uart_es_test.uvprojx, settings and files
target uart_es_test (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GM6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: uart_es_test +hex
  AfterMake: fromelf --bin --output=./Objects/uart_es_test.bin  ./Objects/uart_es_test.axf
  AfterMake: fromelf --text -a -c --output=./Objects/uart_es_test.txt  ./Objects/uart_es_test.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\;..\..\..\..\..\ulibs\hal\gree\include;..\..\..\..\..\..\ulibs\hal\gree\include\common;..\..\..\..\..\ulibs\hal\gree\include\driver;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\..\..\ulibs\hal\gree\include\config;..\..\..\..\include\config;..\..\..\..\..\ulibs\hal\gree\driver;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\can;..\..\..\..\..\ulibs\hal\gree\include\lib\common;..\..\..\..\..\ulibs\hal\gree\arch\arm;..\..\..\..\..\ulibs\hal\gree\driver\dma;..\..\..\..\..\ulibs\hal\gree\driver\uart;..\..\..\..\..\ulibs\hal\gree\driver\gpio;..\..\..\..\..\ulibs\hal\gree\driver\pes;..\..\..\..\..\ulibs\hal\cmsis\Include;..\..\..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\..\..\ulibs\hal\gree\include\arch;..\..\..\..\include\arch;..\..\..\..\..\ulibs\hal\gree\driver\sdram;..\..\..\..\..\ulibs\hal\gree\driver\reset;..\..\..\..\..\ulibs\hal\gree\driver\clock;..\mdk
  library: MicroLIB
  memory RVCT4: ROM 0x20001000 size 0x8000
  memory RVCT9: RAM 0x20009000 size 0x20000
  group prj
    ../: main.c
  group arch
    ../../../../arch/arm/soc/gm6721x/: startup_gm6721x.s
  group common
    ../../../../../ulibs/hal/gree/lib/common/: gm_common.c
    ../../../../common/: printf.c systick.c
  group driver
    ./: pm_system.c
    ../../../../../ulibs/hal/gree/driver/gpio/: gm_hal_gpio.c
    ../../../../../ulibs/hal/gree/driver/uart/: gm_hal_uart.c
    ../../../../../ulibs/hal/gree/driver/dma/: gm_hal_dma.c
    ../../../../../ulibs/hal/gree/driver/clock/: gm_hal_clock.c
    ../../../../../ulibs/hal/gree/driver/reset/: gm_hal_reset.c
    ../../../../../ulibs/hal/gree/driver/hash/: gm_hal_hash.c
    ../: F6721B_ddr_init.c
  group board
    ../../../../boards/f6721b_evb_176pin/: pinmux.c
