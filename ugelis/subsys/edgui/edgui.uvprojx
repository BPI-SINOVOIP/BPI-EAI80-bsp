# Keil uVision project edgui.uvprojx, settings and files
target edgui (ARM-ADS)
  device: F6721BLQFP176 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00010000,0x400000) IRAM(0xC0100000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: edgui (library)
  c flags: Optim=4 oTime=1 uC99=1 wLevel=1
  c define: __USE_KEIL_
  c misc: --gnu
  c include: .\edgui;..\..\include;..\..\include\generated;..\..\include\config;..\..\include\drivers;..\..\arch\arm\include;..\..\kernel\include;..\..\arch\arm\soc\gree_gm\gm6721x;..\..\lib\libc\minimal\include;..\..\boards\arm;..\..\..\ulibs\hal\cmsis\Include;..\..\..\ulibs\hal\gree\include\arch\arm\cpu;..\..\..\ulibs\hal\gree\include\arch\arm\soc;..\..\..\ulibs\hal\gree\driver;..\..\..\ulibs\hal\gree\include\config;..\..\..\ulibs\hal\gree\include\driver;..\..\..\ulibs\hal\gree\include\lib\common
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x400000
  memory RVCT9: RAM 0xc0100000 size 0x20000
  group edgui_core
    ./edgui_core/: edgui_disp.c edgui_group.c edgui_indev.c edgui_obj.c edgui_refr.c edgui_style.c
  group edgui_draw
    ./edgui_draw/: edgui_draw.c edgui_draw_arc.c edgui_draw_basic.c edgui_draw_img.c edgui_draw_label.c edgui_draw_line.c edgui_draw_rect.c edgui_draw_triangle.c edgui_img_cache.c edgui_img_decoder.c
  group edgui_font
    ./edgui_font/: edgui_font.c edgui_font_fmt_txt.c edgui_font_roboto_12.c edgui_font_roboto_16.c edgui_font_roboto_22.c edgui_font_roboto_28.c edgui_font_unscii_8.c
  group edgui_hal
    ./edgui_hal/: edgui_hal_disp.c edgui_hal_indev.c edgui_hal_tick.c
  group edgui_misc
    ./edgui_misc/: edgui_anim.c edgui_area.c edgui_async.c edgui_circ.c edgui_color.c edgui_fs.c edgui_gc.c edgui_ll.c edgui_log.c edgui_math.c edgui_mem.c edgui_task.c edgui_templ.c edgui_txt.c edgui_utils.c
  group edgui_objx
    ./edgui_objx/: edgui_arc.c edgui_bar.c edgui_btn.c edgui_btnm.c edgui_calendar.c edgui_canvas.c edgui_cb.c edgui_chart.c edgui_cont.c edgui_ddlist.c edgui_gauge.c edgui_img.c edgui_imgbtn.c edgui_kb.c edgui_label.c edgui_led.c edgui_line.c edgui_list.c edgui_lmeter.c edgui_mbox.c edgui_objx_templ.c edgui_page.c edgui_preload.c edgui_roller.c edgui_slider.c edgui_spinbox.c edgui_sw.c edgui_ta.c edgui_table.c edgui_tabview.c edgui_tileview.c edgui_win.c
  group edgui_themes
    ./edgui_themes/: edgui_theme.c edgui_theme_alien.c edgui_theme_default.c edgui_theme_material.c edgui_theme_mono.c edgui_theme_nemo.c edgui_theme_night.c edgui_theme_templ.c edgui_theme_zen.c
  group edgui_port
    ./edgui_port/: edgui_port_disp.c edgui_port_fs.c edgui_port_indev.c
